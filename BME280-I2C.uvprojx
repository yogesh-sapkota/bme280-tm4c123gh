# Keil uVision project BME280-I2C.uvprojx, settings and files
target TM4C123GH (6210000::V6.21::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BME280-I2C
  AfterMake: C:\Keil_V5\ARM\ARMCLANG\bin\fromelf.exe --bin --output=.\Objects\BME280-I2C.bin .\Objects\BME280-I2C.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Src
    ./: main.c
    ./drivers/: UART.c gpio.c I2C.c PLL.c SysTick.c bme280.c
software components: CMSIS Driver:I2C:Custom 1.0.0, CMSIS:CORE 5.6.0, Device:Startup 1.0.1
